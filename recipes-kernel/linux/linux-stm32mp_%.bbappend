FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append := " file://0001-add-i2c-userspace-dts.patch"
